## drivers/net/wireless/aic8800/aic_load_fw/Kconfig
```kconfig
config AIC_LOADFW_SUPPORT
	tristate "AIC8800 Load Firmware Support"
	default m
	help
	  This is support for aic wifi driver.
```
